# Keil uVision project openthread_lib_libopenthread_cli_ftd.uvprojx, settings and files
target libopenthread_cli_ftd (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: ..
  output: libopenthread-cli-ftd (library)
  c flags: Optim=s OneElfS=1 uC99=1
  c define: HAVE_CONFIG_H MBEDTLS_CONFIG_FILE=\"mbedtls-config.h\" MBEDTLS_USER_CONFIG_FILE=\"nrf52840-mbedtls-config.h\" OPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED OPENTHREAD_FTD=1 OPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52840-config.h\" _BSD_SOURCE=1 _DEFAULT_SOURCE=1
  c misc: --reduce_paths
  c include: ..\..\..\..\config;..\..\..\..;..\..\..\..\openthread\examples\platforms\nrf52840;..\..\..\..\openthread\examples\platforms\nrf52840\crypto;..\..\..\..\openthread\include;..\..\..\..\openthread\src;..\..\..\..\openthread\src\cli;..\..\..\..\openthread\src\core;..\..\..\..\openthread\third_party\mbedtls;..\..\..\..\openthread\third_party\mbedtls\repo.patched\include;..\..\..\..\openthread\third_party\mbedtls\repo.patched\include\mbedtls
  asm define: as above
  asm misc: --cpreproc_opts=-DHAVE_CONFIG_H,-DMBEDTLS_CONFIG_FILE=\"mbedtls-config.h\",-DMBEDTLS_USER_CONFIG_FILE=\"nrf52840-mbedtls-config.h\",-DOPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED,-DOPENTHREAD_FTD=1,-DOPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52840-config.h\",-D_BSD_SOURCE=1,-D_DEFAULT_SOURCE=1
  asm include: as above
  library: MicroLIB
  link misc: --diag_suppress 6330
  group openthread
    ../../../../openthread/src/cli/: cli.cpp cli_coap.cpp cli_console.cpp cli_dataset.cpp cli_uart.cpp cli_udp_example.cpp
