# Keil uVision project openthread_lib_libopenthread_ncp_mtd.uvprojx, settings and files
target libopenthread_ncp_mtd (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: ..
  output: libopenthread-ncp-mtd (library)
  c flags: Optim=s OneElfS=1 uC99=1
  c define: HAVE_CONFIG_H MBEDTLS_CONFIG_FILE=\"mbedtls-config.h\" MBEDTLS_USER_CONFIG_FILE=\"nrf52840-mbedtls-config.h\" OPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED OPENTHREAD_MTD=1 OPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52840-config.h\" SPINEL_PLATFORM_HEADER=\"spinel_platform.h\" _BSD_SOURCE=1 _DEFAULT_SOURCE=1 _GNU_SOURCE
  c misc: --reduce_paths
  c include: ..\..\..\..\config;..\..\..\..;..\..\..\..\openthread\examples\platforms\nrf52840;..\..\..\..\openthread\examples\platforms\nrf52840\crypto;..\..\..\..\openthread\include;..\..\..\..\openthread\src;..\..\..\..\openthread\src\core;..\..\..\..\openthread\src\ncp;..\..\..\..\openthread\third_party;..\..\..\..\openthread\third_party\mbedtls;..\..\..\..\openthread\third_party\mbedtls\repo.patched\include;..\..\..\..\openthread\third_party\mbedtls\repo.patched\include\mbedtls
  asm define: as above
  asm misc: --cpreproc_opts=-DHAVE_CONFIG_H,-DMBEDTLS_CONFIG_FILE=\"mbedtls-config.h\",-DMBEDTLS_USER_CONFIG_FILE=\"nrf52840-mbedtls-config.h\",-DOPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED,-DOPENTHREAD_MTD=1,-DOPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52840-config.h\",-DSPINEL_PLATFORM_HEADER=\"spinel_platform.h\",-D_BSD_SOURCE=1,-D_DEFAULT_SOURCE=1,-D_GNU_SOURCE
  asm include: as above
  library: MicroLIB
  link misc: --diag_suppress 6330
  group openthread
    ../../../../openthread/src/ncp/: changed_props_set.cpp hdlc.cpp ncp_base.cpp ncp_base_ftd.cpp ncp_base_mtd.cpp ncp_base_radio.cpp ncp_buffer.cpp ncp_spi.cpp ncp_uart.cpp spinel.c spinel_decoder.cpp spinel_encoder.cpp
