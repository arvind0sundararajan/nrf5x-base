# Keil uVision project openthread_lib_libopenthread_platform_utils.uvprojx, settings and files
target libopenthread_platform_utils (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: ..
  output: libopenthread-platform-utils (library)
  c flags: Optim=s OneElfS=1 uC99=1
  c define: HAVE_CONFIG_H MBEDTLS_CONFIG_FILE=\"mbedtls-config.h\" MBEDTLS_USER_CONFIG_FILE=\"nrf52840-mbedtls-config.h\" OPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED OPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52840-config.h\" _BSD_SOURCE=1 _DEFAULT_SOURCE=1
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..;..\..\..\openthread\examples\platforms;..\..\..\openthread\examples\platforms\nrf52840;..\..\..\openthread\examples\platforms\nrf52840\crypto;..\..\..\openthread\examples\platforms\utils;..\..\..\openthread\include;..\..\..\openthread\src\core;..\..\..\openthread\third_party\mbedtls;..\..\..\openthread\third_party\mbedtls\repo.patched\include;..\..\..\openthread\third_party\mbedtls\repo.patched\include\mbedtls
  asm define: as above
  asm misc: --cpreproc_opts=-DHAVE_CONFIG_H,-DMBEDTLS_CONFIG_FILE=\"mbedtls-config.h\",-DMBEDTLS_USER_CONFIG_FILE=\"nrf52840-mbedtls-config.h\",-DOPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED,-DOPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52840-config.h\",-D_BSD_SOURCE=1,-D_DEFAULT_SOURCE=1
  asm include: as above
  library: MicroLIB
  link misc: --diag_suppress 6330
  group openthread
    ../../../openthread/examples/platforms/utils/: debug_uart.c settings.cpp
