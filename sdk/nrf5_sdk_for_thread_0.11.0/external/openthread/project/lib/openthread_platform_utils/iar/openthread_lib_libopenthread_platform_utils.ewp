# IAR project openthread_lib_libopenthread_platform_utils.ewp, settings and files
configuration libopenthread_platform_utils (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: HAVE_CONFIG_H; MBEDTLS_CONFIG_FILE="mbedtls-config.h"; MBEDTLS_USER_CONFIG_FILE="nrf52840-mbedtls-config.h"; OPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED; OPENTHREAD_PROJECT_CORE_CONFIG_FILE="openthread-core-nrf52840-config.h"; _BSD_SOURCE=1; _DEFAULT_SOURCE=1
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..; ..\..\..\openthread\examples\platforms; ..\..\..\openthread\examples\platforms\nrf52840; ..\..\..\openthread\examples\platforms\nrf52840\crypto; ..\..\..\openthread\examples\platforms\utils; ..\..\..\openthread\include; ..\..\..\openthread\src\core; ..\..\..\openthread\third_party\mbedtls; ..\..\..\openthread\third_party\mbedtls\repo.patched\include; ..\..\..\openthread\third_party\mbedtls\repo.patched\include\mbedtls
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: openthread_lib_libopenthread_platform_utils.hex
  ILINK.IlinkOutputFile: openthread_lib_libopenthread_platform_utils.out
  ILINK.IlinkIcfFile: openthread_lib_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group openthread
    ../../../openthread/examples/platforms/utils/: debug_uart.c settings.cpp
