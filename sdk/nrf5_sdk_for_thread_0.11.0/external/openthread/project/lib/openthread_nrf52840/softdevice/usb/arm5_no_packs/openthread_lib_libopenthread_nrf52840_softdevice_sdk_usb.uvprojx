# Keil uVision project openthread_lib_libopenthread_nrf52840_softdevice_sdk_usb.uvprojx, settings and files
target libopenthread_nrf52840_softdevice_sdk_usb (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: ..
  output: libopenthread-nrf52840-softdevice-sdk-usb (library)
  c flags: Optim=s OneElfS=1 uC99=1
  c define: CONFIG_GPIO_AS_PINRESET ENABLE_FEM=1 HAVE_CONFIG_H MBEDTLS_CONFIG_FILE=\"mbedtls-config.h\" MBEDTLS_USER_CONFIG_FILE=\"nrf52840-mbedtls-config.h\" NRF52840_XXAA OPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED OPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52840-config.h\" RAAL_SOFTDEVICE=1 S140 SOFTDEVICE_PRESENT USB_CDC_AS_SERIAL_TRANSPORT=1 _BSD_SOURCE=1 _DEFAULT_SOURCE=1
  c misc: --reduce_paths
  c include: ..\..\..\..\..\config;..\..\..\..\..;..\..\..\..\..\openthread\examples\platforms;..\..\..\..\..\openthread\examples\platforms\nrf52840;..\..\..\..\..\openthread\examples\platforms\nrf52840\crypto;..\..\..\..\..\openthread\include;..\..\..\..\..\openthread\src\core;..\..\..\..\..\openthread\third_party\NordicSemiconductor;..\..\..\..\..\openthread\third_party\NordicSemiconductor\cmsis;..\..\..\..\..\openthread\third_party\NordicSemiconductor\dependencies;..\..\..\..\..\openthread\third_party\NordicSemiconductor\device;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\clock;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\common;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\power;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\raal;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\raal\softdevice;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\systick;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\usbd;..\..\..\..\..\openthread\third_party\NordicSemiconductor\hal;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\atfifo;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\class\cdc;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\class\cdc\acm;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\config;..\..\..\..\..\openthread\third_party\NordicSemiconductor\segger_rtt;..\..\..\..\..\openthread\third_party\NordicSemiconductor\softdevice\s140\headers;..\..\..\..\..\openthread\third_party\mbedtls;..\..\..\..\..\openthread\third_party\mbedtls\repo.patched\include;..\..\..\..\..\openthread\third_party\mbedtls\repo.patched\include\mbedtls
  asm define: as above
  asm misc: --cpreproc_opts=-DCONFIG_GPIO_AS_PINRESET,-DENABLE_FEM=1,-DHAVE_CONFIG_H,-DMBEDTLS_CONFIG_FILE=\"mbedtls-config.h\",-DMBEDTLS_USER_CONFIG_FILE=\"nrf52840-mbedtls-config.h\",-DNRF52840_XXAA,-DOPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED,-DOPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52840-config.h\",-DRAAL_SOFTDEVICE=1,-DS140,-DSOFTDEVICE_PRESENT,-DUSB_CDC_AS_SERIAL_TRANSPORT=1,-D_BSD_SOURCE=1,-D_DEFAULT_SOURCE=1
  asm include: as above
  library: MicroLIB
  link misc: --diag_suppress 6330
  group openthread
    ../../../../../openthread/examples/platforms/nrf52840/: alarm.c diag.c fem.c flash.c flash_sd.c logging.c misc.c platform.c radio.c random.c softdevice.c temp.c uart.c usb-cdc-uart.c
    ../../../../../openthread/third_party/NordicSemiconductor/drivers/radio/: nrf_drv_radio802154.c nrf_drv_radio802154_ack_pending_bit.c nrf_drv_radio802154_critical_section.c nrf_drv_radio802154_debug.c nrf_drv_radio802154_fsm.c nrf_drv_radio802154_notification_swi.c nrf_drv_radio802154_pib.c nrf_drv_radio802154_priority_drop_swi.c nrf_drv_radio802154_request_swi.c nrf_drv_radio802154_rx_buffer.c nrf_drv_radio802154_swi.c
    ../../../../../openthread/third_party/NordicSemiconductor/drivers/radio/fem/: nrf_fem_control_common.c nrf_fem_control_softdevice.c
    ../../../../../openthread/third_party/NordicSemiconductor/drivers/radio/raal/softdevice/: nrf_raal_softdevice.c
