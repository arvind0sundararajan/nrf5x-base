# IAR project openthread_lib_libopenthread_nrf52840_softdevice_sdk_usb.ewp, settings and files
configuration libopenthread_nrf52840_softdevice_sdk_usb (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: CONFIG_GPIO_AS_PINRESET; ENABLE_FEM=1; HAVE_CONFIG_H; MBEDTLS_CONFIG_FILE="mbedtls-config.h"; MBEDTLS_USER_CONFIG_FILE="nrf52840-mbedtls-config.h"; NRF52840_XXAA; OPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED; OPENTHREAD_PROJECT_CORE_CONFIG_FILE="openthread-core-nrf52840-config.h"; RAAL_SOFTDEVICE=1; S140; SOFTDEVICE_PRESENT; USB_CDC_AS_SERIAL_TRANSPORT=1; _BSD_SOURCE=1; _DEFAULT_SOURCE=1
  ICCARM.CCIncludePath2: ..\..\..\..\..\config; ..\..\..\..\..; ..\..\..\..\..\openthread\examples\platforms; ..\..\..\..\..\openthread\examples\platforms\nrf52840; ..\..\..\..\..\openthread\examples\platforms\nrf52840\crypto; ..\..\..\..\..\openthread\include; ..\..\..\..\..\openthread\src\core; ..\..\..\..\..\openthread\third_party\NordicSemiconductor; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\cmsis; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\dependencies; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\device; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\clock; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\common; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\power; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\raal; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\raal\softdevice; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\systick; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\usbd; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\hal; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\atfifo; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\class\cdc; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\class\cdc\acm; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\config; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\segger_rtt; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\softdevice\s140\headers; ..\..\..\..\..\openthread\third_party\mbedtls; ..\..\..\..\..\openthread\third_party\mbedtls\repo.patched\include; ..\..\..\..\..\openthread\third_party\mbedtls\repo.patched\include\mbedtls
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: openthread_lib_libopenthread_nrf52840_softdevice_sdk_usb.hex
  ILINK.IlinkOutputFile: openthread_lib_libopenthread_nrf52840_softdevice_sdk_usb.out
  ILINK.IlinkIcfFile: openthread_lib_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group openthread
    ../../../../../openthread/examples/platforms/nrf52840/: alarm.c diag.c fem.c flash.c flash_sd.c logging.c misc.c platform.c radio.c random.c softdevice.c temp.c uart.c usb-cdc-uart.c
    ../../../../../openthread/third_party/NordicSemiconductor/drivers/radio/: nrf_drv_radio802154.c nrf_drv_radio802154_ack_pending_bit.c nrf_drv_radio802154_critical_section.c nrf_drv_radio802154_debug.c nrf_drv_radio802154_fsm.c nrf_drv_radio802154_notification_swi.c nrf_drv_radio802154_pib.c nrf_drv_radio802154_priority_drop_swi.c nrf_drv_radio802154_request_swi.c nrf_drv_radio802154_rx_buffer.c nrf_drv_radio802154_swi.c
    ../../../../../openthread/third_party/NordicSemiconductor/drivers/radio/fem/: nrf_fem_control_common.c nrf_fem_control_softdevice.c
    ../../../../../openthread/third_party/NordicSemiconductor/drivers/radio/raal/softdevice/: nrf_raal_softdevice.c
