<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\nrf52_iar\iar\mbedtls_openthread_nrf52_library_iar.ewp</path>
  </project>  <batchBuild/>
</workspace>