# IAR project mbedtls_openthread_nrf52_library_iar.ewp, settings and files
configuration mbedtls_openthread_lib (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: MBEDTLS_CONFIG_FILE="mbedtls-config.h"; NRF52840_XXAA
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\device; ..\..\..\..\..\device; ..\..; ..\..\mbedtls; ..\..\..\..\..\toolchain; ..\..\..\..\..\toolchain\cmsis\include; ..\..\..\..\..\..\external\mbedtls\include; ..\..\..\..\..\..\external\mbedtls\include\mbedtls; ..\..\..\..\..\..\external\nrf_cc310\include; ..\..\..\..\..\..\external\openthread\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: MBEDTLS_CONFIG_FILE="mbedtls-config.h"; NRF52840_XXAA
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mbedtls_openthread_nrf52_library_iar.hex
  ILINK.IlinkOutputFile: mbedtls_openthread_nrf52_library_iar.out
  ILINK.IlinkIcfFile: mbedtls_openthread_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_mbedtls
    ../../../../../../external/mbedtls/library/: aes.c bignum.c ccm.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c ecjpake.c ecp_curves.c entropy.c entropy_poll.c md.c md_wrap.c memory_buffer_alloc.c platform.c sha256.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c
    ../../mbedtls/: aes_alt_cc310.c ecp.c sha256_alt_cc310.c
    ../../: cc310_mbedtls.c hardware_entropy.c
