# Keil uVision project mbedtls_openthread_nrf52_library_keil.uvprojx, settings and files
target mbedtls_openthread_lib (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: libmbedcrypto-cc310 (library)
  c flags: Optim=s OneElfS=1 uC99=1
  c define: MBEDTLS_CONFIG_FILE=\"mbedtls-config.h\" NRF52840_XXAA
  c misc: --reduce_paths
  c include: ..\..\config;..\..\..\..\..\device;..\..;..\..\mbedtls;..\..\..\..\..\toolchain;..\..\..\..\..\toolchain\cmsis\include;..\..\..\..\..\..\external\mbedtls\include;..\..\..\..\..\..\external\mbedtls\include\mbedtls;..\..\..\..\..\..\external\nrf_cc310\include;..\..\..\..\..\..\external\openthread\include
  asm define: MBEDTLS_CONFIG_FILE=\"mbedtls-config.h\" NRF52840_XXAA
  asm misc: --cpreproc_opts=-DMBEDTLS_CONFIG_FILE=\"mbedtls-config.h\",-DNRF52840_XXAA
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress 6330
  group nRF_mbedtls
    ../../../../../../external/mbedtls/library/: aes.c bignum.c ccm.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c ecjpake.c ecp_curves.c entropy.c entropy_poll.c md.c md_wrap.c memory_buffer_alloc.c platform.c sha256.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c
    ../../mbedtls/: aes_alt_cc310.c ecp.c sha256_alt_cc310.c
    ../../: cc310_mbedtls.c hardware_entropy.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.15.0
