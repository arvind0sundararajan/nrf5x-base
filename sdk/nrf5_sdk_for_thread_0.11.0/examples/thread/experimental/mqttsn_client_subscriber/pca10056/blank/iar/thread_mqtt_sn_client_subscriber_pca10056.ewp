# IAR project thread_mqtt_sn_client_subscriber_pca10056.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; NRF52840_XXAA; SWI_DISABLE0; UART_ENABLED=0; __HEAP_SIZE=0
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\..\components; ..\..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\..\components\device; ..\..\..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\..\components\libraries\bsp\experimental; ..\..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\..\components\libraries\experimental_log; ..\..\..\..\..\..\..\components\libraries\experimental_log\src; ..\..\..\..\..\..\..\components\libraries\experimental_memobj; ..\..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\components\thread\experimental\mqtt_sn\mqtt_sn_client; ..\..\..\..\..\..\..\components\thread\experimental\utils; ..\..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\..\external\nrf_cc310\include; ..\..\..\..\..\..\..\external\openthread\include; ..\..\..\..\..\..\..\external\paho\mqtt-sn\mqttsn_packet; ..\..\..\..\..\..\..\external\segger_rtt; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: thread_mqtt_sn_client_subscriber_pca10056.hex
  ILINK.IlinkOutputFile: thread_mqtt_sn_client_subscriber_pca10056.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\external\openthread\linker_scripts\openthread_nrf52840.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nrf_cc310
    ../../../../../../../external/nrf_cc310/lib/: libcc310_iar7.x_0.9.0.a
  group nRF_Log
    ../../../../../../../components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group Board Definition
    ../../../../../../../components/boards/: boards.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../../../components/libraries/strerror/: nrf_strerror.c
  group openthread
    ../../../../../../../external/openthread/lib/iar/: libopenthread-cli-ftd.a libopenthread-ftd.a libopenthread-nrf52840-sdk.a libopenthread-platform-utils.a libopenthread-diag.a libmbedcrypto-cc310.a
  group nRF_Drivers
    ../../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../../../components/drivers_nrf/hal/: nrf_nvmc.c
  group Board Support
    ../../../../../../../components/libraries/bsp/: bsp.c bsp_nfc.c
    ../../../../../../../components/libraries/bsp/experimental/: bsp_thread.c
  group nRF-Thread
    ../../../../../../../external/paho/mqtt-sn/mqttsn_packet/: MQTTSNConnectClient.c MQTTSNConnectServer.c MQTTSNDeserializePublish.c MQTTSNPacket.c MQTTSNSearchClient.c MQTTSNSearchServer.c MQTTSNSerializePublish.c MQTTSNSubscribeClient.c MQTTSNSubscribeServer.c MQTTSNUnsubscribeClient.c MQTTSNUnsubscribeServer.c
  group nRF_Segger_RTT
    ../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_printf.c
  group Device
    ../../../../../../../components/toolchain/iar/: iar_startup_nrf52840.s
    ../../../../../../../components/toolchain/: system_nrf52840.c
  group nRF_Thread
    ../../../../../../../components/thread/experimental/mqtt_sn/mqtt_sn_client/: mqttsn_client.c mqttsn_packet_fifo.c mqttsn_packet_receiver.c mqttsn_packet_sender.c mqttsn_platform.c mqttsn_transport_ot.c
    ../../../../../../../components/thread/experimental/utils/: thread_assert.c thread_utils.c
